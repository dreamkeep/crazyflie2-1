# Keil uVision project crazyflie2-nrf-mbs.uvprojx, settings and files
target crazyflie2-nrf-mbs (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: crazyflie2-nrf-mbs
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\crazyflie2-nrf-mbs\include;..\crazyflie2-nrf-mbs\include\nrf;..\crazyflie2-nrf-mbs\include\cm0;.\s110\s110_nrf51822_7.0.0_API\include;.\src
  asm define: __NO_VECTORS
  library: MicroLIB
  memory RVCT4: ROM 0x3f000 size 0x1000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group src
    ../crazyflie2-nrf-mbs/src/: main.c crc.c
    ./src/: arm_startup_nrf51.s
    ../crazyflie2-nrf-mbs/: system_nrf51.c
