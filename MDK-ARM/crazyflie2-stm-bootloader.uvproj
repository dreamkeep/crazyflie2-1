# Keil uVision project crazyflie2-stm-bootloader.uvproj, settings and files
target crazyflie2-stm-bootloader (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: crazyflie2-stm-bootloader
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4XX STM32F40_41xxx HSE_VALUE=8000000 USE_STDPERIPH_DRIVER
  c misc: --c99 --gnu --diag_suppress=1295
  c include: ..\crazyflie2-stm-bootloader\include;..\crazyflie2-stm-bootloader\lib\STM32F4xx_StdPeriph_Driver\inc;..\crazyflie2-stm-bootloader\lib\STM32_CPAL_Driver\inc;..\crazyflie2-stm-bootloader\lib\STM32_CPAL_Driver\devices\stm32f4xx;..\crazyflie2-stm-bootloader\lib\CMSIS\STM32F4xx\Include;..\crazyflie2-stm-bootloader\lib\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: startup_stm32f405xx.s
    ../crazyflie2-stm-bootloader/src/: bootpin.c main.c syslink.c uart.c
    ../crazyflie2-stm-bootloader/lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group lib
    ../crazyflie2-stm-bootloader/lib/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_misc.c stm32f4xx_flash.c
