# Keil uVision project crazyflie2-nrf-bootloader.uvprojx, settings and files
target crazyflie2-nrf-bootloader (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: crazyflie2-nrf-bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --gnu --preinclude sys-gnu.h --preinclude systick.h --diag_suppress=1295
  c include: ..\crazyflie2-nrf-bootloader\include\nrf;..\crazyflie2-nrf-bootloader\include;.\s110\s110_nrf51822_7.0.0_API\include;.\nrf51_sdk\nrf51822\Include\gcc;.\nrf51_sdk\nrf51822\Include;.\nrf51_sdk\nrf51822\Include\ble;.\nrf51_sdk\nrf51822\Include\ble\ble_services;.\nrf51_sdk\nrf51822\Include\app_common;.\nrf51_sdk\nrf51822\Include\sd_common;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group src
    ./src/: arm_startup_nrf51.s
    ../crazyflie2-nrf-bootloader/: system_nrf51.c
    ../crazyflie2-nrf-bootloader/src/: main.c button.c systick.c ble.c ble_crazyflies.c esb.c timeslot.c bootloader.c uart.c syslink.c crc.c
  group nrf51_sdk
    ./nrf51_sdk/nrf51822/Source/ble/: ble_advdata.c ble_conn_params.c
    ./nrf51_sdk/nrf51822/Source/ble/ble_services/: ble_srv_common.c ble_dis.c
    ./nrf51_sdk/nrf51822/Source/sd_common/: softdevice_handler.c
    ./nrf51_sdk/nrf51822/Source/app_common/: app_timer.c
