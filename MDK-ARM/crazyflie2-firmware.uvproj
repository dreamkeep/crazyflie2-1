# Keil uVision project crazyflie2-firmware.uvproj, settings and files
target crazyflie2-firmware (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: crazyflie2-firmware
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4XX HSE_VALUE=8000000 USE_STDPERIPH_DRIVER
  c misc: --gnu --c99 --preinclude src\sys-gnu.h --diag_suppress=1295
  c include: .\src;..\crazyflie-firmware\lib\FreeRTOS\include;..\crazyflie-firmware\lib\FreeRTOS\portable\RVDS\ARM_CM3;..\crazyflie-firmware\config;..\crazyflie-firmware\hal\interface;..\crazyflie-firmware\modules\interface;..\crazyflie-firmware\utils\interface;..\crazyflie-firmware\drivers\interface;..\crazyflie-firmware\platform;..\crazyflie-firmware\lib\CMSIS\Include;..\crazyflie-firmware\lib\STM32F4xx_StdPeriph_Driver\inc;..\crazyflie-firmware\lib\STM32_CPAL_Driver\inc;..\crazyflie-firmware\lib\STM32_USB_Device_Library\Core\inc;..\crazyflie-firmware\lib\STM32_USB_OTG_Driver\inc;..\crazyflie-firmware\lib\STM32_CPAL_Driver\devices\stm32f4xx;..\crazyflie-firmware\lib\CMSIS\STM32F4xx\Include
  asm define: __PRINT_HARDFAIL
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\crazyflie2-firmware.sct
  group init
    ../crazyflie-firmware/init/: main.c
    ./src/: version.c
  group platform
    ../crazyflie-firmware/platform/cf2/: platform_cf2.c
  group drivers
    ../crazyflie-firmware/drivers/src/: led.c exti.c nvic.c mpu6500.c motors_f405.c i2cdev_f405.c ws2812.c lps25h.c ak8963.c eeprom.c uart_syslink.c swd.c
  group hal
    ../crazyflie-firmware/hal/src/: usbd_usr.c usb_bsp.c usblink.c usbd_desc.c usb.c ledseq.c freeRTOSdebug.c syslink.c imu_cf2.c pm_f405.c radiolink.c ow.c
  group modules
    ../crazyflie-firmware/modules/src/: crtp.c system.c comm.c console.c pid.c crtpservice.c param.c mem.c platformservice.c commander.c controller.c sensfusion6.c stabilizer.c log.c worker.c neopixelring.c expbrd.c exptest.c
  group utils
    ../crazyflie-firmware/utils/src/: filter.c cpuid.c cfassert.c configblockeeprom.c eprintf.c crc.c fp16.c debug.c
  group lib/CMSIS
    ./src/: startup_stm32f405xx.s
    ../crazyflie-firmware/lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group lib/FreeRTOS
    ../crazyflie-firmware/lib/FreeRTOS/: list.c tasks.c queue.c timers.c
    ../crazyflie-firmware/lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../crazyflie-firmware/lib/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group lib/STM32F4xx_StdPeriph_Driver
    ../crazyflie-firmware/lib/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_misc.c stm32f4xx_syscfg.c
  group lib/STM32_CPAL_Driver
    ../crazyflie-firmware/lib/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback_template.c
    ../crazyflie-firmware/lib/STM32_CPAL_Driver/devices/stm32f4xx/: cpal_i2c_hal_stm32f4xx.c
  group lib/STM32_USB_OTG_Driver
    ../crazyflie-firmware/lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd_int.c usb_dcd.c
  group lib/STM32_USB_Device_Library
    ../crazyflie-firmware/lib/STM32_USB_Device_Library/Core/src/: usbd_ioreq.c usbd_req.c usbd_core.c
